## Config.in
```kconfig
config BR2_PACKAGE_USERSCHEDTEST
    bool "test software for SCHED_USER policy"
    help
      Sofware for testing SCHED_USER policy
```
